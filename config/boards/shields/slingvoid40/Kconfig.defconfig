## config/boards/shields/slingvoid40/Kconfig.defconfig
```kconfig
if SHIELD_SLINGVOID40

config ZMK_KEYBOARD_NAME
    default "slingvoid40"

endif
```
